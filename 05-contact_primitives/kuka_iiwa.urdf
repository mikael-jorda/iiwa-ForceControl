Commit message: added cube end effector and pos/ori tasks

File: 05-contact_primitives/kuka_iiwa.urdf (robot description, URDF)
Before this commit: robot kuka_iiwa/meshes, 8 links, 7 joints
Links:
- link link6: geometry collision box size=0.08 0.08 0.08; visual box size=0.08 0.08 0.08
